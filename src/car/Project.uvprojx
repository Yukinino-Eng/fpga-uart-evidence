# Keil uVision project Project.uvprojx, settings and files
target Lesson20 UART PYNQ (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0xFC00) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lesson20Uart +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Start;.\Library;.\User;.\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\fixed_reference.sct
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group System
    ./System/: team_car.c team_car.h Delay.c Delay.h l1_tick.c l1_tick.h l2_key.c l2_key.h l7_motor.c l7_motor.h l4_mpu6050.c l4_mpu6050.h l8_uart.c l8_uart.h l10_timing.c l10_timing.h l5_gyro_cal.c l5_gyro_cal.h l7_encoder.c l7_encoder.h l12_pitch.c l12_pitch.h l13_button.c l13_button.h l15_policy.c l15_policy.h l12_pd.c l12_pd.h l15_motor_guard.c l15_motor_guard.h l18_control.c l18_control.h l15_settings.h l16_reference.c l16_reference.h l18_speed.c l18_speed.h l20_task.c l20_task.h l18_output.c l18_output.h l18_sync.c l18_sync.h l16_position_monitor.c l16_position_monitor.h parallel_pid_config.h
